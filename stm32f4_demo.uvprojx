# Keil uVision project stm32f4_demo.uvprojx, settings and files
target stm32f4_demo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32f4_demo +hex
  AfterMake: D:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin  -o  .\Objects\stm32f4_demo.bin .\Objects\stm32f4_demo.axf
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: .\CMSIS\Device\ST\STM32F4xx\Include;.\Libraries\inc;.\System\delay;.\System\sys;.\System\usart;.\CMSIS\Include;.\System;.\FreeRTOSv9.0.0\Source\include;.\FreeRTOSv9.0.0\Source\portable\RVDS\ARM_CM4F;.\FreeRTOSv9.0.0;.\Tasks\UserTasks;.\Software;..\stm32f4_freertos_demo_keil
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./User/: main.c
    ./CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
  group Tasks
    ./Tasks/UserTasks/: usertask.c uarttask.c
  group System
    ./System/delay/: delay.c
    ./System/sys/: sys.c
    ./System/usart/: usart.c
    ./System/: stm32f4xx_it.c
  group Hardware
    ./Hardware/LED/: led.c
  group Startup
    ./Startup/arm/: startup_stm32f40_41xxx.s
  group CMSIS
    ./CMSIS/Device/ST/STM32F4xx/Source/: system_stm32f4xx.c
  group Libraries
    ./Libraries/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group FreeRTOSv9.0.0/Source
    ./FreeRTOSv9.0.0/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOSv9.0.0/Port
    ./FreeRTOSv9.0.0/Source/portable/RVDS/ARM_CM4F/: port.c
    ./FreeRTOSv9.0.0/Source/portable/MemMang/: heap_4.c
    ./FreeRTOSv9.0.0/: FreeRTOSConfig.h
  group Software
    ./Software/: message_manager.c
